Commit message: change dynamic and add path planning

File: assets/cube.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link base_link: mass None -> 1.0
